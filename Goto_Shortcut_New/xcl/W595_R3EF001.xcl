-carm

-Z(CODE)STANDBY_SOFTKEY_RIGHT=
-Z(CODE)STANDBY_LINK_RIGHT=

-Z(CODE)ZAMAIN,CODE,DATA_C,INITTAB=
