-carm

-Z(CODE)STANDBY_SOFTKEY_RIGHT=116CEBEC
-Z(CODE)STANDBY_LINK_RIGHT=116CEBF0

-Z(CODE)CODE,DATA_C,INITTAB=120E83A0 //12100A80
