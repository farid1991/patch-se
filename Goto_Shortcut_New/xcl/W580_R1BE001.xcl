-carm

-Z(CODE)STANDBY_SOFTKEY=452BFA04
-Z(CODE)STANDBY_LINK=452BFA00

-Z(CODE)CODE,DATA_C,INITTAB=45DDA000
