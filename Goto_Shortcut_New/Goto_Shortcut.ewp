# IAR project Goto_Shortcut.ewp, settings and files
configuration G502_R1FA037 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: A2; DB3150v1; G502_R1FA037
  ICCARM.PreInclude: Target\G502_R1FA037.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: DB3150v1; G502_R1FA037; RIGHT
  XLINK.XclFile: xcl\G502_R1FA037.xcl
configuration J105_R1HA035 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; DB3210; J105_R1HA035; RIGHT
  ICCARM.PreInclude: Target\J105_R1HA035.h
  AARM.ADefines: DB3210; J105_R1HA035; RIGHT
  XLINK.XclFile: xcl\J105_R1HA035.xcl
configuration C510_R1HA035 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; A2; DB3210; C510_R1HA035
  ICCARM.PreInclude: Target\C510_R1HA035.h
  AARM.ADefines: A2; DB3210; C510_R1HA035
  XLINK.XclFile: xcl\C510_R1HA035.xcl
configuration W580_R8BE001 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: A1; DB2020; W580_R8BE001
  ICCARM.PreInclude: Target\W580_R8BE001.h
  AARM.ADefines: A1; DB2020; W580_R8BE001
  XLINK.XclFile: xcl\W580_R1BE001.xcl
  group (top)
    ../include/: dll.c
    ./: editor.c FileFolder.c main.c strlib.c utils.c
  group asm
    asm/: C510_R1HA035.asm G502_R1FA037.asm J105_R1HA035.asm W580_R8BE001.lib.asm
