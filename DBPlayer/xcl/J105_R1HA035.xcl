//J105_R1HA035
-carm
-Z(CODE)CODE,DATA_C,INITTAB=15C55300
-Z(CODE)CREATE_GUI=14D54BCC