//U10_R7AA071
-carm
-Z(CODE)CODE,DATA_C=162BDCB0
-Z(CODE)CREATE_GUI=15109804
-Z(CODE)MME_DATA_FIX=15CF3670