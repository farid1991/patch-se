-carm
-Z(CODE)CODE,DATA_C,INITTAB=15F00000
-Z(CODE)CREATE_GUI=1509DFC8