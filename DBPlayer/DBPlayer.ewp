# IAR project DBPlayer.ewp, settings and files
configuration C901_R1GA028 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG; A2; DB3210; C901_R1GA028
  ICCARM.PreInclude: Target\C901_R1GA028.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: A2; DB3210; C901_R1GA028
  XLINK.XclFile: xcl\C901_R1GA028.xcl
configuration J105_R1HA035 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; A2; DB3200; J105_R1HA035
  ICCARM.PreInclude: Target\J105_R1HA035.h
  AARM.ADefines: J105_R1HA035; A2; DB3200
  XLINK.XclFile: xcl\J105_R1HA035.xcl
configuration C510_R1HA035 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; A2; DB3210; C510_R1HA035
  ICCARM.PreInclude: Target\C510_R1HA035.h
  AARM.ADefines: C510_R1HA035; A2; DB3210
  XLINK.XclFile: xcl\C510_R1HA035.xcl
configuration W995_R1GA026 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; A2; DB3210; W995_R1GA026
  ICCARM.PreInclude: Target\W995_R1GA026.h
  AARM.ADefines: W995_R1GA026; A2; DB3210
  XLINK.XclFile: xcl\W995_R1GA026.xcl
configuration C905_R1FA035 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; A2; DB3210; C905_R1FA035
  ICCARM.PreInclude: Target\C905_R1FA035.h
  AARM.ADefines: C905_R1FA035; A2; DB3210
  XLINK.XclFile: xcl\C905_R1FA035.xcl
configuration G502_R1FA037 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; A2; DB3150v1; G502_R1FA037
  ICCARM.PreInclude: Target\G502_R1FA037.h
  AARM.ADefines: G502_R1FA037; A2; DB3150v1
  XLINK.XclFile: xcl\G502_R1FA037.xcl
  group (top)
    ./: data.c drow.c editor.c info.c lang.c main.c setting.c time.c
  group asm
    asm/: C510_R1FA035_Orange.asm C510_R1HA035.asm C901_R1GA028.asm C905_R1FA035.asm G502_R1FA037.asm J105_R1HA035.asm W995_R1GA026.asm
