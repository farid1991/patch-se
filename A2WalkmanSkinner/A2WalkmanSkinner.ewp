# IAR project A2WalkmanSkinner.ewp, settings and files
configuration C510_R1HA035 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration C702_R3EF001 (ARM)
  as the first configuration, except:
configuration G502_R1FA037 (ARM)
  as the first configuration, except:
configuration K660_R1FA037 (ARM)
  as the first configuration, except:
configuration T715_R1GA026 (ARM)
  as the first configuration, except:
configuration W508_R1FA035 (ARM)
  as the first configuration, except:
configuration W595_R3EF001 (ARM)
  as the first configuration, except:
configuration W715_R1GA030 (ARM)
  as the first configuration, except:
configuration W760_R3EM001 (ARM)
  as the first configuration, except:
configuration W890_R1FA035 (ARM)
  as the first configuration, except:
configuration W910_R1FA037 (ARM)
  as the first configuration, except:
configuration W902_R3EG004 (ARM)
  as the first configuration, except:
configuration W980_R3EG004 (ARM)
  as the first configuration, except:
configuration W995_R1HA035 (ARM)
  as the first configuration, except:
  group (top)
    ./: CurrentTrack.c dll.c Draw.c Editor.c FilesList.c main.c SaveLoad.c String.c
  group ASM
    temp/: temp.asm
  group GUI
    GUI/: AdvLyric.c Clearbass.c Dialog.c EditColor.c EditCoordinates.c NowPlaying.c SelectFont.c TimeInput.c
  group Pages
    Pages/: AlbumArt.c EditTag.c Equalizer.c Lyric.c SetTime.c Shortcut.c Skins.c TimerOff.c UseAs.c
