# IAR project MusicApp_ShutdownTimer.ewp, settings and files
configuration G502_R1FA037 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration U10_R1BA049 (ARM)
  as the first configuration, except:
  group (top)
    ./: main.c
  group ASM
    temp/: temp.asm
