//U10_R1BA049
-carm
-Z(CODE)CODE,DATA_C,INITTAB=16201F70
-Z(CODE)PATCH_MUSIC_SOFTKEYS=146586C0
-Z(CODE)PATCH_MUSIC_DESTROY=141FBD00
