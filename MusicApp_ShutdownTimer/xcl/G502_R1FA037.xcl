//G502_R1FA037
-carm
-Z(CODE)CODE,DATA_C,INITTAB=120EA980
-Z(CODE)PATCH_MUSIC_SOFTKEYS=115B9330 //115B92D0
-Z(CODE)PATCH_MUSIC_DESTROY=115B8488
