# IAR project SMSBackup.ewp, settings and files
configuration G502_R1FA037 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8f.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG; A2; G502_R1FA037; DB3150
  ICCARM.PreInclude: Target\G502_R1FA037.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: G502_R1FA037; A2; DB3150
  XLINK.XclFile: xcl\G502_R1FA037.xcl
  group (top)
    ./: main.c
  group ASM
    asm/: G502_R1FA037.asm
