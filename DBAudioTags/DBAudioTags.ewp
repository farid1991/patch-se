# IAR project DBAudioTags.ewp, settings and files
configuration C510_R1HA035 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG; A2; DB3210; C510_R1HA035
  ICCARM.PreInclude: Target\C510_R1HA035.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: A2; DB3210; C510_R1HA035
  XLINK.XclFile: xcl\C510_R1HA035.xcl
configuration G502_R1FA037 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; A2; DB3150v1; G502_R1FA037
  ICCARM.PreInclude: Target\G502_R1FA037.h
  AARM.ADefines: A2; DB3150v1; G502_R1FA037
  XLINK.XclFile: xcl\G502_R1FA037.xcl
  group (top)
    ./: main.c
  group asm
    asm/: G502_R1FA037.asm
