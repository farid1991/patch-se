-carm

-Z(CODE)FREE_SPACE,CODE,DATA_C,INITTAB=127AE6F0
-Z(CODE)PATCH_VOLUMEONPAGENTER=11FF5848
-Z(CODE)PATCH_VOLUMEONPAGEXIT=11FF5850
-Z(CODE)PATCH_VOLUMEONREDRAW=11ADCE14