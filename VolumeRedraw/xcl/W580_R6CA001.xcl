-carm

-Z(CODE)FREE_SPACE,CODE,DATA_C,INITTAB=45C2C740

-Z(CODE)PATCH_VOLUMEONPAGENTER=45BAD614

-Z(CODE)PATCH_VOLUMEONPAGEXIT=45BAD61C

-Z(CODE)PATCH_VOLUMEONREDRAW=452E8EAC








