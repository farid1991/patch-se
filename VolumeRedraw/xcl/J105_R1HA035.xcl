-carm

-Z(CODE)FREE_SPACE,CODE,DATA_C,INITTAB=15C46B40



-Z(CODE)PATCH_VOLUMEONREDRAW=14ED0594
-Z(CODE)PATCH_VOLUMEONPAGENTER=15B4B820
-Z(CODE)PATCH_VOLUMEONPAGEXIT=15B4B828




