-carm

-Z(CODE)FREE_SPACE,CODE,DATA_C,INITTAB=12793860
-Z(CODE)PATCH_VOLUMEONPAGENTER=11F2BFB0
-Z(CODE)PATCH_VOLUMEONPAGEXIT=11F2BFB8
-Z(CODE)PATCH_VOLUMEONREDRAW=11AB72E4