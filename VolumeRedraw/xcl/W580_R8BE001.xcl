-carm

-Z(CODE)FREE_SPACE,CODE,DATA_C,INITTAB=45DB1CF0

-Z(CODE)PATCH_VOLUMEONPAGENTER=45BAB6D0

-Z(CODE)PATCH_VOLUMEONPAGEXIT=45BAB6D8

-Z(CODE)PATCH_VOLUMEONREDRAW=452BB408








