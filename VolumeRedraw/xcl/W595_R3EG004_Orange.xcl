-carm

-Z(CODE)FREE_SPACE,CODE,DATA_C,INITTAB=126D2000
-Z(CODE)PATCH_VOLUMEONPAGENTER=11FB14DC
-Z(CODE)PATCH_VOLUMEONPAGEXIT=11FB14E4
-Z(CODE)PATCH_VOLUMEONREDRAW=11B3A830