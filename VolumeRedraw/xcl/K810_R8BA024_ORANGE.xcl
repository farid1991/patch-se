-carm

-Z(CODE)FREE_SPACE,CODE,DATA_C,INITTAB=45D24400

-Z(CODE)PATCH_VOLUMEONPAGENTER=45C944A8

-Z(CODE)PATCH_VOLUMEONPAGEXIT=45C944B0

-Z(CODE)PATCH_VOLUMEONREDRAW=45401850