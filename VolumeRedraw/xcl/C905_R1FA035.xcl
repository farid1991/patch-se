-carm

-Z(CODE)FREE_SPACE,CODE,DATA_C,INITTAB=15E0FA60



-Z(CODE)PATCH_VOLUMEONREDRAW=14F5B564
-Z(CODE)PATCH_VOLUMEONPAGENTER=15D07FE8
-Z(CODE)PATCH_VOLUMEONPAGEXIT=15D07FF0






