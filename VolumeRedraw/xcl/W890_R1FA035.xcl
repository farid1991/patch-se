-carm

-Z(CODE)FREE_SPACE,CODE,DATA_C,INITTAB=121f5050

-Z(CODE)PATCH_VOLUMEONPAGENTER=11BD0968
-Z(CODE)PATCH_VOLUMEONPAGEXIT=11BD0970
-Z(CODE)PATCH_VOLUMEONREDRAW=11721FB0 
