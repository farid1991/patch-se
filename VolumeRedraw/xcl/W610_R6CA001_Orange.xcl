-carm

-Z(CODE)FREE_SPACE,CODE,DATA_C,INITTAB=45BFF000

-Z(CODE)PATCH_VOLUMEONPAGENTER=45A70AA4

-Z(CODE)PATCH_VOLUMEONPAGEXIT=45A70AAC

-Z(CODE)PATCH_VOLUMEONREDRAW=452E79E4