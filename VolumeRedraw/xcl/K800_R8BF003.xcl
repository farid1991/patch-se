-carm

-Z(CODE)FREE_SPACE,CODE,DATA_C,INITTAB=45CF94E0

-Z(CODE)PATCH_VOLUMEONPAGENTER=45C500FC

-Z(CODE)PATCH_VOLUMEONPAGEXIT=45C50104

-Z(CODE)PATCH_VOLUMEONREDRAW=453BB594








