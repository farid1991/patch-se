-carm

-Z(CODE)FREE_SPACE,CODE,DATA_C,INITTAB=15F14050



-Z(CODE)PATCH_VOLUMEONREDRAW=14EDC65C
-Z(CODE)PATCH_VOLUMEONPAGENTER=15C1E81C
-Z(CODE)PATCH_VOLUMEONPAGEXIT=15C1E824






