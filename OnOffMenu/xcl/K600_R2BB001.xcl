//K600_R2BB001
-carm
-Z(CODE)CODE,DATA_C=21478230
-Z(CODE)PATCH_STANDBY_EVENT=2025C75C
