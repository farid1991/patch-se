# IAR project OnOffMenu.ewp, settings and files
configuration K600_R2BB001 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
  group (top)
    ./: main.c
  group ASM
    temp/: temp.asm
