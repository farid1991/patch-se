# IAR project DBItemText.ewp, settings and files
configuration C510_R1HA035 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration G502_R1FA037 (ARM)
  as the first configuration, except:
configuration W715_R1GA030 (ARM)
  as the first configuration, except:
configuration W995_R1HA035 (ARM)
  as the first configuration, except:
  group (top)
    ./: main.c
  group asm
    temp/: temp.asm
