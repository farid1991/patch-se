# IAR project Backlight.ewp, settings and files
configuration C510_R1HA035 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration C901_R1GA028 (ARM)
  as the first configuration, except:
configuration G502_R1FA037 (ARM)
  as the first configuration, except:
configuration U10_R7AA071 (ARM)
  as the first configuration, except:
configuration W660_R8BB001 (ARM)
  as the first configuration, except:
configuration W980_R3EG004 (ARM)
  as the first configuration, except:
  group (top)
    ./: book_list.c bright_input.c Data.c main.c string_input.c time_input.c
  group ASM
    temp/: temp.asm
