//G502_R1FA037
-carm
-Z(CODE)START,CODE,DATA_C,INITTAB=12224000 //12100A80
-Z(CODE)PATCH_DB_NEWSOFTKEY=1101D830
