# IAR project BookManagerMod.ewp, settings and files
configuration C510_R1FA035_Orange (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration G502_R1FA037 (ARM)
  as the first configuration, except:
configuration W508_R1FA035 (ARM)
  as the first configuration, except:
configuration W760_R3EM001 (ARM)
  as the first configuration, except:
configuration W810_R4EA031 (ARM)
  as the first configuration, except:
configuration W980_R3EG004 (ARM)
  as the first configuration, except:
configuration W995_R1GA026 (ARM)
  as the first configuration, except:
  group (top)
    ./: main.c
  group asm
    temp/: temp.asm
