# IAR project BookManager.ewp, settings and files
configuration C510_R1FA035_Orange (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG; A2; DB3210; C510_R1FA035_Orange
  ICCARM.PreInclude: Target\C510_R1FA035_Orange.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: C510_R1FA035_Orange; A2; DB3210
  XLINK.XclFile: xcl\C510_R1FA035_Orange.xcl
configuration G502_R1FA037 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; A2; DB3150v1; G502_R1FA037
  ICCARM.PreInclude: Target\G502_R1FA037.h
  AARM.ADefines: G502_R1FA037; A2; DB3150v1
  XLINK.XclFile: xcl\G502_R1FA037.xcl
configuration K800_R8BF003 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; K800_R8BF003; DB2020
  ICCARM.PreInclude: Target\K800_R8BF003.h
  AARM.ADefines: K800_R8BF003; DB2020
  XLINK.XclFile: xcl\K800_R8BF003.xcl
configuration C510_R1HA035 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: A2; DB3210; C510_R1HA035
  ICCARM.PreInclude: Target\C510_R1HA035.h
  AARM.ADefines: C510_R1HA035; A2; DB3210
  XLINK.XclFile: xcl\C510_R1HA035.xcl
  group (top)
    ./: main.c string.c Utils.c
  group asm
    asm/: C510_R1FA035_Orange.asm C510_R1HA035.asm G502_R1FA037.asm K800_R8BF003.asm
  group tab
    ./: tab_books.c tab_elfs.c tab_shortcuts.c
