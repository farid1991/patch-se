-carm

-Z(CODE)PATCH_BODY,CODE,DATA_C,DATA_Z,INITTAB=121B0000

-Z(CODE)PATCH_VolumeFunc=11A6E8F0-11A6E8F3 // Standart