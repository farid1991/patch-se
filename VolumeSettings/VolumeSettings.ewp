# IAR project VolumeSettings.ewp, settings and files
configuration C510_R1HA035 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration G502_R1FA037 (ARM)
  as the first configuration, except:
configuration W595_R3EF001 (ARM)
  as the first configuration, except:
  group (top)
    ./: dll.c main.c ReadFile.c
  group asm
    temp/: temp.asm
