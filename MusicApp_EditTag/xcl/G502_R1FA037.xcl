-carm

-Z(CODE)PATCH_ADD_SOFTKEYS=115B9570
-Z(CODE)CODE,DATA_C,INITTAB=121887B0
