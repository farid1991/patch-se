# IAR project Standby_Clear.ewp, settings and files
configuration W660_R8BB001_Orange (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG; DB2020; W660_R8BB001_Orange
  ICCARM.PreInclude: Target\W660_R8BB001_Orange.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: W660_R8BB001_Orange; DB2020
  XLINK.XclFile: xcl\W660_R8BB001_Orange.xcl
configuration K800_R8BF003 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; DB2020; K800_R8BF003
  ICCARM.PreInclude: Target\K800_R8BF003.h
  AARM.ADefines: K800_R8BF003; DB2020
  XLINK.XclFile: xcl\K800_R8BF003.xcl
configuration W995_R1GA026 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; A2; W995_R1GA026
  ICCARM.PreInclude: Target\W995_R1GA026.h
  AARM.ADefines: W995_R1GA026; A2
  XLINK.XclFile: xcl\W995_R1GA026.xcl
configuration k790_R8BF003 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; DB2020; k790_R8BF003
  ICCARM.PreInclude: Target\k790_R8BF003.h
  AARM.ADefines: K790_R8BF003; DB2020
  XLINK.XclFile: xcl\k790_R8BF003.xcl
configuration C510_R1HA035 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; A2; C510_R1HA035
  ICCARM.PreInclude: Target\C510_R1HA035.h
  AARM.ADefines: C510_R1HA035; A2
  XLINK.XclFile: xcl\C510_R1HA035.xcl
configuration W800_R1BD001 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; DB2010; W800_R1BD001
  ICCARM.PreInclude: Target\W800_R1BD001.h
  AARM.ADefines: W800_R1BD001; DB2010
  XLINK.XclFile: xcl\W800_R1BD001.xcl
configuration W760_R3EF001 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; A2; W760_R3EF001
  ICCARM.PreInclude: Target\W760_R3EF001.h
  AARM.ADefines: W760_R3EF001; A2
  XLINK.XclFile: xcl\W760_R3EF001.xcl
configuration W595_R3FE001 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; A2; W595_R3FE001
  ICCARM.PreInclude: Target\W595_R3FE001.h
  AARM.ADefines: W595_R3FE001; A2
  XLINK.XclFile: xcl\W595_R3FE001.xcl
configuration C510_R1FA035 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; A2; C510_R1FA035
  ICCARM.PreInclude: Target\C510_R1FA035.h
  AARM.ADefines: C510_R1FA035; A2
  XLINK.XclFile: xcl\C510_R1FA035.xcl
configuration K810_R8BF003 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; DB2020; K810_R8BF003
  ICCARM.PreInclude: Target\K810_R8BF003.h
  AARM.ADefines: K810_R8BF003; DB2020
  XLINK.XclFile: xcl\K810_R8BF003.xcl
configuration W660_R8BB001 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; DB2020; W660_R8BB001
  ICCARM.PreInclude: Target\W660_R8BB001.h
  AARM.ADefines: W660_R8BB001; DB2020
  XLINK.XclFile: xcl\W660_R8BB001.xcl
configuration W580_R8BE001 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; DB2020; W580_R8BE001
  ICCARM.PreInclude: Target\W580_R8BE001.h
  AARM.ADefines: W580_R8BE001; DB2020
  XLINK.XclFile: xcl\W580_R8BE001.xcl
configuration C901_R1GA028 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; A2; C901_R1GA028
  ICCARM.PreInclude: Target\C901_R1GA028.h
  AARM.ADefines: C901_R1GA028; A2
  XLINK.XclFile: xcl\C901_R1GA028.xcl
configuration W810_R4EA031 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; DB2010; W810_R4EA031
  ICCARM.PreInclude: Target\W810_R4EA031.h
  AARM.ADefines: W810_R4EA031; DB2010
  XLINK.XclFile: xcl\W810_R4EA031.xcl
configuration C905_R1FA035 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; A2; C905_R1FA035
  ICCARM.PreInclude: Target\C905_R1FA035.h
  AARM.ADefines: C905_R1FA035; A2
  XLINK.XclFile: xcl\C905_R1FA035.xcl
configuration G502_R1FA037 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; A2; DB3150v1; G502_R1FA037
  ICCARM.PreInclude: Target\G502_R1FA037.h
  AARM.ADefines: G502_R1FA037; A2; DB3150v1
  XLINK.XclFile: xcl\G502_R1FA037.xcl
  group (top)
    ./: main.c
  group asm
    asm/: C510_R1FA035.asm C510_R1HA035.asm C901_R1GA028.asm C905_R1FA035.asm G502_R1FA037.asm k790_R8BF003.asm K800_R8BF003.asm K810_R8BF003.asm W580_R8BE001.asm W595_R3FE001.asm W660_R8BB001.asm W660_R8BB001_Orange.asm W760_R3EF001.asm W800_R1BD001.asm W810_R4EA031.asm W995_R1GA026.asm
