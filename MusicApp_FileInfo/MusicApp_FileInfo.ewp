# IAR project MusicApp_FileInfo.ewp, settings and files
configuration U10_R1BA049 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
  group (top)
    ./: main.c
  group ASM
    temp/: temp.asm
