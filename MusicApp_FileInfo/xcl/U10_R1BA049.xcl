//U10_R1BA049
-carm
-Z(CODE)CODE,DATA_C,INITTAB=16201B60
-Z(CODE)PATCH_ADD_SOFTKEYS=146587A0
