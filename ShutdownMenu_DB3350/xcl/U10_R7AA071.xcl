//U10_R7AA071
-carm
-Z(CODE)CODE,DATA_C=162CC5A0
-Z(CODE)PATCH_NEW_SHUTDOWN=14598710
