//U100_R7AA076
-carm
-Z(CODE)CODE,DATA_C=16026000
-Z(CODE)PATCH_NEW_SHUTDOWN=14579580
