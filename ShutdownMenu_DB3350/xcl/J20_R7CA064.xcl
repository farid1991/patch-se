//J20_R7CA064
-carm
-Z(CODE)CODE,DATA_C=15F60000
-Z(CODE)PATCH_NEW_SHUTDOWN=142EA058
