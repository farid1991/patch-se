//J108_R7EA011
-carm
-Z(CODE)CODE,DATA_C=15D62250
-Z(CODE)PATCH_NEW_SHUTDOWN=142E0BDC
