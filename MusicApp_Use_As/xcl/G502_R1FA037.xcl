//G502_R1FA037
-carm
-Z(CODE)CODE,DATA_C,INITTAB=120E8000
-Z(CODE)PATCH_ADD_SOFTKEYS=115B95CC
