-carm

-Z(CODE)PATCH_ADD_SOFTKEYS=115B95CC
-Z(CODE)CODE,DATA_C,INITTAB=120E8000
