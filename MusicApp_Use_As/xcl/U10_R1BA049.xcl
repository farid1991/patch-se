//U10_R1BA049
-carm
-Z(CODE)CODE,DATA_C,INITTAB=162017D0
-Z(CODE)PATCH_ADD_SOFTKEYS=1465877C
