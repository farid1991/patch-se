//U10_R1BA049
-carm
-Z(CODE)CODE,DATA_C,INITTAB=162C4160
-Z(CODE)PATCH_ADD_SOFTKEYS=1465877C
