//U10_R7AA071
-carm
-Z(CODE)CODE,DATA_C=162C4080
-Z(CODE)PATCH_ADD_SOFTKEYS=14651088
