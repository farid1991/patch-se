# IAR project DataCounter.ewp, settings and files
configuration G502_R1FA037 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG; A2; DB3150v1; G502_R1FA037
  ICCARM.PreInclude: Target\G502_R1FA037.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: A2; DB3150v1; G502_R1FA037
  XLINK.XclFile: xcl\G502_R1FA037.xcl
  group (top)
    ./: main.c
  group ASM
    asm/: G502_R1FA037.asm
