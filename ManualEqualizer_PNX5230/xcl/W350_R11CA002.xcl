//W350_R11CA002
-carm
-Z(CODE)CODE,DATA_C=21900000
-Z(CODE)PATCH_EQ_SOFTKEYS=20D2DFD8