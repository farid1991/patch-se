# IAR project AdvPlayer.ewp, settings and files
configuration W700_R1CA021 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration W800_R1BD001 (ARM)
  as the first configuration, except:
configuration W810_R4EA031 (ARM)
  as the first configuration, except:
  group (top)
    ./: CurrentTrack.c data.c draw.c main.c MetaData.c skinselect.c StrLib.c toplevel.c
  group ASM
    temp/: temp.asm
