# IAR project OLED.ewp, settings and files
configuration G502_R1FA037 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG; A2; G502_R1FA037; DB3150v1
  ICCARM.PreInclude: Target\G502_R1FA037.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: G502_R1FA037; A2; DB3150v1
  XLINK.XclFile: xcl\G502_R1FA037.xcl
configuration J105_R1HA035 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8f.h
  ICCARM.CCDefines: NDEBUG; A2; J105_R1HA035; DB3200
  ICCARM.PreInclude: Target\J105_R1HA035.h
  AARM.ADefines: A2; J105_R1HA035; DB3200
  XLINK.XclFile: xcl\J105_R1HA035.xcl
  group (top)
    ./: main.c
  group ASM
    asm/: G502_R1FA037.asm J105_R1HA035.asm
