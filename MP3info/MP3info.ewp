# IAR project MP3info.ewp, settings and files
configuration C510_R1HA035 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
  group (top)
    ./: id3v2.c main.c
  group ASM
    temp/: temp.asm
