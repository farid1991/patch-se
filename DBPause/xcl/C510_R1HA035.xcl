-carm
-Z(CODE)CODE,DATA_C=15D80000
-Z(CODE)SOFTKEY=14CC0EB0
-Z(CODE)SOFTKEY_ADD=14CC0E24