//U10_R7AA071
-Z(CODE)CODE,DATA_C=162BCD60
-Z(CODE)SOFTKEY=1510989C
-Z(CODE)SOFTKEY_ADD=1510982C
-Z(CODE)SOFTKEY_FIX_PAUSE=15109818