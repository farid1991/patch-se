//U10_R1BA049
-carm
-Z(CODE)CODE,DATA_C=16201710
-Z(CODE)SOFTKEY=150E8120
-Z(CODE)SOFTKEY_ADD=150E80B0
-Z(CODE)SOFTKEY_FIX=150E809C