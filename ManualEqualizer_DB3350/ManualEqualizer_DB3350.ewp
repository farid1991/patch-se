# IAR project ManualEqualizer_DB3350.ewp, settings and files
configuration J20_R7CA064 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration U100_R7AA076 (ARM)
  as the first configuration, except:
  group (top)
    ./: Clearbass.c dll.c main.c
  group ASM
    temp/: temp.asm
