//J20_R7CA064
-carm
-Z(CODE)CODE,DATA_C=15F60F10
-Z(CODE)PATCH_SET_EQ=147C1D18
-Z(CODE)PATCH_SET_EQGAIN=147C20AC
-Z(CODE)PATCH_EQ_SOFTKEYS=14A67A00
