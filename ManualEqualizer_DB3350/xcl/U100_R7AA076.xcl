//U100_R7AA076
-carm
-Z(CODE)CODE,DATA_C=1602B4A0
-Z(CODE)PATCH_SET_EQ=14F6C828
-Z(CODE)PATCH_SET_EQGAIN=14F6C8E4 
-Z(CODE)PATCH_EQ_SOFTKEYS=1462A934
