# IAR project StandbyMode.ewp, settings and files
configuration C510_R1HA035 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
  group (top)
    ./: dll.c draw.c edit_color.c editor.c item_text.c standby_data.c main.c
  group ASM
    temp/: temp.asm
