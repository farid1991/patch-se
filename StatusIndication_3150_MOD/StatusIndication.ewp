# IAR project StatusIndication.ewp, settings and files
configuration G502_R1FA037 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG; A2; DB3150v1; G502_R1FA037
  ICCARM.PreInclude: Target\G502_R1FA037.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: G502_R1FA037; A2; DB3150v1
  XLINK.XclFile: xcl\G502_R1FA037.xcl
  group (top)
    ./: config_data.c div.r79 editor.c GetSignalQuality.c StatusIndication.c visual.cpp
  group ASM
    asm/: C702_R3EF001.asm C902_R3EG004AS.asm G502_R1FA037.asm K850_R1FA035.asm W595_R3EF001.asm W595_R3EG004_Orange.asm W760_R3EF001.asm W890_R1FA035.asm W910_R1FA037.asm
