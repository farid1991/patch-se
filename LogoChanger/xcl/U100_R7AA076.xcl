//U100_R7AA076
-carm
-Z(CODE)CODE,DATA_C=1602ED20

-Z(CODE)PATCH_GET_NEWOPNAME=151B8858
-Z(CODE)PATCH_NEW_EVENTLIST=15943A48
