//W660_R8BB001
-carm
-Z(CODE)CODE,DATA_C=45DBE170

-Z(CODE)PATCH_GET_NEWOPNAME=44EFB964
-Z(CODE)PATCH_NEW_EVENTLIST=45AB8BE8
