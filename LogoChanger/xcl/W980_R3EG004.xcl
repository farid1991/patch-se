//W980_R3EG004
-carm
-Z(CODE)CODE,DATA_C=127D3B30

-Z(CODE)PATCH_GET_NEWOPNAME=10FC8CC4
-Z(CODE)PATCH_NEW_EVENTLIST=11B4BD28
