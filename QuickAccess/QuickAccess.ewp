# IAR project QuickAccess.ewp, settings and files
configuration W350_R11CA002 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration W900_R5BC004 (ARM)
  as the first configuration, except:
configuration W980_R3EG004 (ARM)
  as the first configuration, except:
  group (top)
    ./: main.c
  group ASM
    temp/: temp.asm
