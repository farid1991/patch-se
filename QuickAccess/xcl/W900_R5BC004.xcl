//W900_R5BC004
-carm
-Z(CODE)CODE,DATA_C=21A6D000
-Z(CODE)PATCH_QuickAccessMenu_EnterEvent=2149019C
