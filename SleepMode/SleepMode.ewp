# IAR project SleepMode.ewp, settings and files
configuration G502_R1FA037 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration K600_R2BB001 (ARM)
  as the first configuration, except:
configuration W350_R11CA002 (ARM)
  as the first configuration, except:
configuration W810_R4EA031 (ARM)
  as the first configuration, except:
  group (top)
    ./: main.c
  group ASM
    temp/: temp.asm
