//G502_R1FA037
-carm
-Z(CODE)CODE,DATA_C=121831F0 //120A4C90
-Z(CODE)PATCH_TIMER_SET=116DC9D0
-Z(CODE)PATCH_TIMER_KILL=116DCA3C
-Z(CODE)PATCH_SLEEPMODE_ONREDRAW=116DCFC8
