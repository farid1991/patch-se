-carm

-Z(CODE)PATCH_DRAWSCREENSAVER=116DCFC8
-Z(CODE)PATCH_TIMER_RUN=116DC9D0
-Z(CODE)PATCH_TIMER_KILL=116DCA3C


-Z(CODE)PATCH_BODY,CODE,DATA_C,INITTAB=121831F0 //120A4C90
