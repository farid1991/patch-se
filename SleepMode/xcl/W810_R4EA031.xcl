//W810_R4EA031
-carm
-Z(CODE)CODE,DATA_C=456D93E0 //456D8AB0
-Z(CODE)PATCH_TIMER_SET=452AB328
-Z(CODE)PATCH_TIMER_KILL=452AB3C8
-Z(CODE)PATCH_SLEEPMODE_ONREDRAW=452ABC30
