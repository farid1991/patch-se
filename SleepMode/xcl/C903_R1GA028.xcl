//C903_R1GA028
-carm
-Z(CODE)CODE,DATA_C=15E41BD0
-Z(CODE)PATCH_TIMER_SET=142D8968
-Z(CODE)PATCH_TIMER_KILL=14236C34
-Z(CODE)PATCH_SLEEPMODE_ONREDRAW=14508720
