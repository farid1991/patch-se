//W660_R8BB001
-carm
-Z(CODE)CODE,DATA_C=45DBDE10
-Z(CODE)PATCH_TIMER_SET=454B9578
-Z(CODE)PATCH_TIMER_KILL=454B95FC
-Z(CODE)PATCH_SLEEPMODE_ONREDRAW=454B9B5C
