//W200_R4HA014
-carm
-Z(CODE)CODE,DATA_C=4555A2D0
-Z(CODE)PATCH_TIMER_SET=4511F3D8
-Z(CODE)PATCH_TIMER_KILL=4511F478
-Z(CODE)PATCH_SLEEPMODE_ONREDRAW=4511FCE0
