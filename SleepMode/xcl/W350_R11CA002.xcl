//W350_R11CA002
-carm
-Z(CODE)CODE,DATA_C=21900080
-Z(CODE)PATCH_TIMER_SET=21131494
-Z(CODE)PATCH_TIMER_KILL=21131520
-Z(CODE)PATCH_SLEEPMODE_ONREDRAW=21131A90
