//K600_R2BB001
-carm
-Z(CODE)CODE,DATA_C=21474000
-Z(CODE)PATCH_TIMER_SET=2027A618
-Z(CODE)PATCH_TIMER_KILL=2027A6B8
-Z(CODE)PATCH_SLEEPMODE_ONREDRAW=2027AF34
