//U100_R7AA076
-carm
-Z(CODE)CODE,DATA_C=1602FB80
-Z(CODE)PATCH_TIMER_SET=143D7564
-Z(CODE)PATCH_TIMER_KILL=140FD8D4
-Z(CODE)PATCH_SLEEPMODE_ONREDRAW=1428B110
