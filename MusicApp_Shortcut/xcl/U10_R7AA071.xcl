//U10_R7AA071
-carm
-Z(CODE)CODE,DATA_C,INITTAB=162BC000
-Z(CODE)PATCH_MUSIC_SOFTKEYS=14650FD8
-Z(CODE)PATCH_MUSIC_KEYBOARD=1541134C
