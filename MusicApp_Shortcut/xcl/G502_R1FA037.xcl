//G502_R1FA037
-carm
-Z(CODE)PATCH_NEW_ACTION=115B96F0
-Z(CODE)PATCH_NEW_KEY=115B9FA8
-Z(CODE)CODE,DATA_C,INITTAB=120EA130
