//W508_R1FA035
-carm
-Z(CODE)CODE,DATA_C,INITTAB=15CD4EB0
-Z(CODE)PATCH_MUSIC_KEYBOARD1=14D2C31C
-Z(CODE)PATCH_MUSIC_KEYBOARD2=14F08C00
-Z(CODE)PATCH_MUSIC_SOFTKEYS=145B4A08 
