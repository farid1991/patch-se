//W980_R3EG004
-carm
-Z(CODE)CODE,DATA_C,INITTAB=127CA050
-Z(CODE)PATCH_MUSIC_SOFTKEYS=10C86A18
-Z(CODE)PATCH_MUSIC_KEYBOARD1=10C855B0
-Z(CODE)PATCH_MUSIC_KEYBOARD2=10C85EB0
