//K630_R1FA032
-carm
-Z(CODE)CODE,DATA_C=12019880
-Z(CODE)PATCH_MUSIC_SOFTKEYS=1154D524
-Z(CODE)PATCH_MUSIC_KEYBOARD1=1154C7D8
-Z(CODE)PATCH_MUSIC_KEYBOARD2=1154C2B8
