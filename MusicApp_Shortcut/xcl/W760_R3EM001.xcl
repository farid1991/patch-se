//W760_R3EM001
-carm
-Z(CODE)CODE,DATA_C,INITTAB=12815000
-Z(CODE)PATCH_MUSIC_SOFTKEYS=10D23410
-Z(CODE)PATCH_MUSIC_KEYBOARD1=10D21F80
-Z(CODE)PATCH_MUSIC_KEYBOARD2=10D2273C
