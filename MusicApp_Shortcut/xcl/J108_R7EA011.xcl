//J108_R7EA011
-carm
-Z(CODE)CODE,DATA_C=15D62410
-Z(CODE)PATCH_MUSIC_SOFTKEYS=14A075C0
-Z(CODE)PATCH_MUSIC_KEYBOARD=147EFB20
