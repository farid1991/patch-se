//U10_R1BA049
-carm
-Z(CODE)CODE,DATA_C,INITTAB=162024E0
-Z(CODE)PATCH_MUSIC_SOFTKEYS=146586CC
-Z(CODE)PATCH_MUSIC_KEYBOARD=143BE540
