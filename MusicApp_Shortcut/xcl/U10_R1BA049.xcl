//U10_R1BA049
-carm
-Z(CODE)CODE,DATA_C,INITTAB=16202500
-Z(CODE)PATCH_MUSIC_SOFTKEYS=146586CC
-Z(CODE)PATCH_MUSIC_KEYBOARD=143BE540
