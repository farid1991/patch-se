//C510_R1HA035
-carm
-Z(CODE)CODE,DATA_C,INITTAB=15DDB000
-Z(CODE)PATCH_NEW_ACTION=14F15060
-Z(CODE)PATCH_NEW_KEY=14430150
