//C510_R1HA035
-carm
-Z(CODE)CODE,DATA_C,INITTAB=15DDB000
-Z(CODE)PATCH_MUSIC_KEYBOARD1=14D44480
-Z(CODE)PATCH_MUSIC_KEYBOARD2=14F152C0
-Z(CODE)PATCH_NEW_SOFTKEYS=14F15060 
