//C510_R1HA035
-carm
-Z(CODE)CODE,DATA_C,INITTAB=15DDB000
-Z(CODE)PATCH_MUSIC_KEYBOARD=14430150
-Z(CODE)PATCH_MUSIC_SOFTKEYS=14F15060 
