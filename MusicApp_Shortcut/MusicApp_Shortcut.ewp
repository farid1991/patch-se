# IAR project MusicApp_Shortcut.ewp, settings and files
configuration G502_R1FA037 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration C510_R1HA035 (ARM)
  as the first configuration, except:
configuration U10_R1BA049 (ARM)
  as the first configuration, except:
configuration U10_R7AA071 (ARM)
  as the first configuration, except:
  group (top)
    ./: main.c
  group ASM
    temp/: temp.asm
