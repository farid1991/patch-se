# IAR project FlashMenuPicker.ewp, settings and files
configuration C510_R1HA035 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration C903_R1GA028 (ARM)
  as the first configuration, except:
configuration C905_R1FA035 (ARM)
  as the first configuration, except:
configuration F100_R1HA035 (ARM)
  as the first configuration, except:
configuration J20_R7CA064 (ARM)
  as the first configuration, except:
configuration T707_R1FA035 (ARM)
  as the first configuration, except:
configuration U10_R7AA071 (ARM)
  as the first configuration, except:
configuration U100_R7AA076 (ARM)
  as the first configuration, except:
configuration W550_R4CB020 (ARM)
  as the first configuration, except:
configuration W595_R3EF001 (ARM)
  as the first configuration, except:
configuration W715_R1GA030 (ARM)
  as the first configuration, except:
configuration W760_R3EM001 (ARM)
  as the first configuration, except:
configuration W810_R4EA031 (ARM)
  as the first configuration, except:
configuration W900_R5BC004 (ARM)
  as the first configuration, except:
configuration W902_R3EG004 (ARM)
  as the first configuration, except:
configuration W910_R1FA037 (ARM)
  as the first configuration, except:
configuration W980_R3EG004 (ARM)
  as the first configuration, except:
configuration W995_R1HA035 (ARM)
  as the first configuration, except:
  group (top)
    ./: main.c
  group asm
    temp/: temp.asm
