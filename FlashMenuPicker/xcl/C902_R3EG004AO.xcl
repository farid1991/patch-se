//C902_R3EG004AO
-carm
-Z(CODE)CODE,DATA_C=127FE030
-Z(CODE)PATCH_FD_SOFTKEYS=10DC0DC4
