//W715_R1GA030
-carm
-Z(CODE)CODE,DATA_C=15DE2100
-Z(CODE)PATCH_FD_SOFTKEYS=14DA1EC0
