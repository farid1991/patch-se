//J20_R7CA064
-carm
-Z(CODE)CODE,DATA_C=15F640C0
-Z(CODE)PATCH_FD_SOFTKEYS=14FF8958