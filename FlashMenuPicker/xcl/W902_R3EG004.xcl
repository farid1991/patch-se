//W902_R3EG004
-carm
-Z(CODE)CODE,DATA_C=12825000
-Z(CODE)PATCH_FD_SOFTKEYS=10DE5034
