//W900_R5BC004
-carm
-Z(CODE)CODE,DATA_C=21A71000
-Z(CODE)PATCH_MM_SOFTKEYS=20721500
