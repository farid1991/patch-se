//W910_R1FA037
-carm
-Z(CODE)CODE,DATA_C=12242000
-Z(CODE)PATCH_FD_SOFTKEYS=11238850
-Z(CODE)PATCH_MM_SOFTKEYS=116954C8
