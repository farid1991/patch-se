//C510_R1HA035
-carm
-Z(CODE)CODE,DATA_C=15DD9890
-Z(CODE)PATCH_FD_SOFTKEYS=14CE0CEC
