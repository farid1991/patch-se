//W810_R4EA031
-carm
-Z(CODE)CODE,DATA_C=457F12D0
-Z(CODE)PATCH_FD_SOFTKEYS=4526F868
-Z(CODE)PATCH_MM_SOFTKEYS=4553AA9C
