//W995_R1HA035
-carm
-Z(CODE)CODE,DATA_C=15F02010
-Z(CODE)PATCH_FD_SOFTKEYS=155184E0
