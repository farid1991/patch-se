//U10_R7AA071
-carm
-Z(CODE)CODE,DATA_C=162CC760
-Z(CODE)PATCH_FD_SOFTKEYS=15668E10
