//U100_R7AA076
-carm
-Z(CODE)CODE,DATA_C=1602C660
-Z(CODE)PATCH_FD_SOFTKEYS=15442FBC
