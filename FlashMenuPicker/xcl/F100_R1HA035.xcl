//F100_R1HA035
-carm
-Z(CODE)CODE,DATA_C=15CB5000
-Z(CODE)PATCH_FD_SOFTKEYS=153EDD40
