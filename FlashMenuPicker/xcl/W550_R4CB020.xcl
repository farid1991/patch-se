//W550_R4CB020
-carm
-Z(CODE)CODE,DATA_C=45700000
-Z(CODE)PATCH_FD_SOFTKEYS=45196EBC
-Z(CODE)PATCH_MM_SOFTKEYS=4545D9E8
