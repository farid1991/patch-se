//W595_R3EF001
-carm
-Z(CODE)CODE,DATA_C=127F1000
-Z(CODE)PATCH_FD_SOFTKEYS=10DDD0C0
