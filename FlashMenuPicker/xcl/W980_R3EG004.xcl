//W980_R3EG004
-carm
-Z(CODE)CODE,DATA_C=127BC350
-Z(CODE)PATCH_FD_SOFTKEYS=10DDC32C
