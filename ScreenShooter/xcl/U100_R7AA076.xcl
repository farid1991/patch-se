//U100_R7AA076
-carm
-Z(CODE)CODE,DATA_C,INITTAB=1602F3B0
-Z(CODE)PATCH_NEW_KEYHANDLER=14267F10
-Z(CODE)PATCH_GAMEBUTTON_A=1591C440
-Z(CODE)PATCH_GAMEBUTTON_B=1591C4A8
