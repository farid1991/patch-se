//T707_R1FA035
-carm

-Z(CODE)CODE,DATA_C=15C90000
-Z(CODE)PATCH_START_TIMER=141B5754
-Z(CODE)PATCH_KILL_TIMER=14EE92D4

-Z(CODE)Patch_OLED=15A2AFFC-15A2AFFF
-Z(CODE)Patch_Run_OLED=15A2B000-15A2B003