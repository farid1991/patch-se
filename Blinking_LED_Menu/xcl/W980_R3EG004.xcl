//W980_R3EG004
-carm
-Z(CODE)CODE,DATA_C=127CADA0
-Z(CODE)PATCH_START_TIMER=10BF239C
-Z(CODE)PATCH_KILL_TIMER=10BF2730
-Z(CODE)Patch_OLED=11B9035C-11B9035F
-Z(CODE)Patch_Run_OLED=11B90360-11B90363
