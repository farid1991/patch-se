//W508_R1FA035
-carm

-Z(CODE)CODE,DATA_C=15CD44B0
-Z(CODE)PATCH_START_TIMER=141B61B4
-Z(CODE)PATCH_KILL_TIMER=14F153D0

-Z(CODE)Patch_OLED=15A616F8-15A616FB
-Z(CODE)Patch_Run_OLED=15A616FC-15A616FF