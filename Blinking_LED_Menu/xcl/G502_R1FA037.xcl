//G502_R1FA037
-carm

-Z(CODE)CODE,DATA_C=121903A0
-Z(CODE)PATCH_START_TIMER=116E7574
-Z(CODE)PATCH_KILL_TIMER=116E787C
-Z(CODE)Patch_OLED=11A6EC7C-11A6EC7F
-Z(CODE)Patch_Run_OLED=11A6EC80-11A6EC83
