# IAR project StandbyManager.ewp, settings and files
configuration W660_R8BB001_Orange (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration K800_R8BF003 (ARM)
  as the first configuration, except:
configuration W995_R1GA026 (ARM)
  as the first configuration, except:
configuration C510_R1HA035 (ARM)
  as the first configuration, except:
configuration W800_R1BD001 (ARM)
  as the first configuration, except:
configuration W760_R3EF001 (ARM)
  as the first configuration, except:
configuration W595_R3FE001 (ARM)
  as the first configuration, except:
configuration C510_R1FA035 (ARM)
  as the first configuration, except:
configuration K810_R8BF003 (ARM)
  as the first configuration, except:
configuration W660_R8BB001 (ARM)
  as the first configuration, except:
configuration W580_R8BE001 (ARM)
  as the first configuration, except:
configuration C901_R1GA028 (ARM)
  as the first configuration, except:
configuration W810_R4EA031 (ARM)
  as the first configuration, except:
configuration C905_R1FA035 (ARM)
  as the first configuration, except:
configuration G502_R1FA037 (ARM)
  as the first configuration, except:
configuration W980_R3EG004 (ARM)
  as the first configuration, except:
configuration U10_R7AA071 (ARM)
  as the first configuration, except:
  group (top)
    ./: main.c
  group asm
    temp/: temp.asm
