# IAR project ImageID_Viewer.ewp, settings and files
configuration G502_R1FA037 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: A2; DB3150v1; G502_R1FA037
  ICCARM.PreInclude: Target\G502_R1FA037.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: A2; DB3150v1; G502_R1FA037
  XLINK.XclFile: xcl\G502_R1FA037.xcl
configuration C510_R1HA035 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: A2; DB3210; C510_R1HA035
  ICCARM.PreInclude: Target\C510_R1HA035.h
  AARM.ADefines: A2; DB3210; C510_R1HA035
  XLINK.XclFile: xcl\C510_R1HA035.xcl
  group (top)
    ../include/: dll.c
    ./: gui_imageviewer.c main.c string.c
  group asm
    asm/: C510_R1HA035.asm G502_R1FA037.asm
