-carm

-Z(CODE)CODE,DATA_C,INITTAB=15DD4000

-Z(CODE)PATCH_SET_TEXTS=14C2FD30
-Z(CODE)PATCH_SET_ACTION=14DF8E18
-Z(CODE)PATCH_FIX_SETCURSOR=14C2FD20
