-carm

-Z(CODE)PATCH_SET_TEXTS=112509FC
-Z(CODE)PATCH_SET_ACTION=11250A50
-Z(CODE)PATCH_FIX_SETCURSOR=112509EC

-Z(CODE)CODE,DATA_C,INITTAB=12193C80 //120E0710
