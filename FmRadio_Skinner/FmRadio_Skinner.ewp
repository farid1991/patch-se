# IAR project FmRadio_Skinner.ewp, settings and files
configuration G502_R1FA037 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: A2; DB3150v1; G502_R1FA037
  ICCARM.PreInclude: Target\G502_R1FA037.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: A2; DB3150v1; G502_R1FA037
  XLINK.XclFile: xcl\G502_R1FA037.xcl
configuration W995_R1HA035 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  ICCARM.CCDefines: A2; DB3210; W995_R1HA035
  ICCARM.PreInclude: Target\W995_R1HA035.h
  AARM.ADefines: A2; DB3210; W995_R1HA035
  XLINK.XclFile: xcl\W995_R1HA035.xcl
configuration W995_R1GA026 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  ICCARM.CCDefines: A2; DB3210; W995_R1GA026
  ICCARM.PreInclude: Target\W995_R1GA026.h
  AARM.ADefines: A2; DB3210; W995_R1GA026
  XLINK.XclFile: xcl\W995_R1GA026.xcl
  group (top)
    ./: data.c draw.c editor.c info.c lang.c main.c setting.c
    ../include/: dll.c
  group ASM
    asm/: G502_R1FA037.asm W995_R1GA026.asm W995_R1HA035.asm
