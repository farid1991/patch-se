//U10_R1BA049

-carm
-Z(CODE)CODE,DATA_C=162015B0
-Z(CODE)ALARM_LIST=1412FFF0
-Z(CODE)ALARM_STANDBY=145EF674
