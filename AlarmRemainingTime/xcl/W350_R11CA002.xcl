//W350_R11CA002

-carm
-Z(CODE)CODE,DATA_C=21903C80
-Z(CODE)ALARM_LIST=20BC1F7C
-Z(CODE)ALARM_STANDBY=21068B30
