//C510_R1HA035

-carm
-Z(CODE)CODE,DATA_C=15D85B50
-Z(CODE)ALARM_LIST=1517A6E4
-Z(CODE)ALARM_STANDBY=141ACA2C
