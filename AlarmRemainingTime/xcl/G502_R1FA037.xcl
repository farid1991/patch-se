//G502_R1FA037

-carm
-Z(CODE)CODE,DATA_C=12100000
-Z(CODE)ALARM_LIST=10F33CEC
-Z(CODE)ALARM_STANDBY=1160F9E8
