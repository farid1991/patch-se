-carm
-Z(CODE)CODE,DATA_C=45BD19C0
-Z(CODE)ALARM_LIST=44DA0B44
-Z(CODE)ALARM_STANDBY=4528725C