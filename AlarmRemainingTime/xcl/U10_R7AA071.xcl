//U10_R7AA071
-carm
-Z(CODE)CODE,DATA_C=162BCE40
-Z(CODE)ALARM_LIST=1412D220 
-Z(CODE)ALARM_STANDBY=145E7F44 
