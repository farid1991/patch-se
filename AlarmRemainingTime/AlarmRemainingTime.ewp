# IAR project AlarmRemainingTime.ewp, settings and files
configuration C510_R1HA035 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration K800_R8BF003 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
configuration K550_R8BA024 (ARM)
  as the first configuration, except:
configuration G502_R1FA037 (ARM)
  as the first configuration, except:
configuration U10_R1BA049 (ARM)
  as the first configuration, except:
configuration U10_R7AA071 (ARM)
  as the first configuration, except:
  group (top)
    ./: main.c
  group asm
    temp/: temp.asm
