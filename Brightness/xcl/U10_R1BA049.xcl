//U10_R1BA049
-carm
-Z(CODE)CODE,DATA_C=16203280
-Z(CODE)DS_CREATE=15BE89E0
-Z(CODE)DS_CLOSE=15BE89E8
-Z(CODE)ITEM_TEXT=147EC490
-Z(CODE)BR_1=1538C076
-Z(CODE)BR_2=1538C07A
