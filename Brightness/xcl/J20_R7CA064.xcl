//J20_R7CA064
-carm
-Z(CODE)CODE,DATA_C=15F60210
-Z(CODE)DS_CREATE=157BFE48
-Z(CODE)DS_CLOSE=157BFE50
-Z(CODE)ITEM_TEXT=14B10AEC
-Z(CODE)BR_1=14C1A262
-Z(CODE)BR_2=14C1A266
