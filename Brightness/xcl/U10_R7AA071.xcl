//U10_R7AA071
-carm
-Z(CODE)CODE,DATA_C=162BCFA0
-Z(CODE)DS_CREATE=15BFD694
-Z(CODE)DS_CLOSE=15BFD69C
-Z(CODE)ITEM_TEXT=147DFDDC
-Z(CODE)BR_1=153AC2E2
-Z(CODE)BR_2=153AC2E6
