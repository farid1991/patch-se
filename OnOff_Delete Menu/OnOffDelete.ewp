# IAR project OnOffDelete.ewp, settings and files
configuration G502_R1FA037 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG; A2; G502_R1FA037; DB3150
  ICCARM.PreInclude: Target\G502_R1FA037.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: G502_R1FA037; A2; DB3150
  XLINK.XclFile: xcl\G502_R1FA037.xcl
configuration W580_R8BE001 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; W580_R8BE001; DB2020
  ICCARM.PreInclude: Target\W580_R8BE001.h
  AARM.ADefines: W580_R8BE001; DB2020
  XLINK.XclFile: xcl\W580_R8BE001.xcl
  group (top)
    ./: main.c
  group ASM
    asm/: G502_R1FA037.asm W580_R8BE001.asm
