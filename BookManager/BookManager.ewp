# IAR project BookManager.ewp, settings and files
configuration U10_R1BA049 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
  group (top)
    ./: main.c string.c
  group asm
    temp/: temp.asm
