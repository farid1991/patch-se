-carm

-Z(CODE)START,CODE,DATA_C,INITTAB=1272D500

-Z(CODE)_TEXT=10840060

