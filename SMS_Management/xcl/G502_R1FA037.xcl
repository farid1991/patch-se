-carm

-Z(CODE)PATCH_NEW_ACTION=113B5644
-Z(CODE)PATCH_BODY,CODE,DATA_C,INITTAB=12190FE0
