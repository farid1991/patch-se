# IAR project WalkmanButton.ewp, settings and files
configuration W350_R11CA002 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
  group (top)
    ./: bookman.c book_names.c main.c screenshot.c shortcut.c StrLib.c
  group ASM
    temp/: temp.asm
