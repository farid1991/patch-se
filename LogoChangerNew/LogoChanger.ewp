# IAR project LogoChanger.ewp, settings and files
configuration G502_R1FA037 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: A2; DB3150v1; G502_R1FA037
  ICCARM.PreInclude: Target\G502_R1FA037.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: A2; DB3150v1; G502_R1FA037
  XLINK.XclFile: xcl\G502_R1FA037.xcl
configuration W660_R8BB001_Orange (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DB2020; W660_R8BB001_Orange
  ICCARM.PreInclude: Target\W660_R8BB001_Orange.h
  AARM.ADefines: DB2020; W660_R8BB001_Orange
  XLINK.XclFile: xcl\W660_R8BB001_Orange.xcl
  group (top)
    ./: main.c
  group ASM
    asm/: G502_R1FA037.asm w660_r8bb001_Orange.asm
