-carm

-Z(CODE)PATCH_BACK_ACT=44EDC180
-Z(CODE)PATCH_GET_OPNAME=44F307A8
-Z(CODE)PATCH_NEW_PG=45AE5918

-Z(CODE)PATCH_BODY,CODE,DATA_C,INITTAB=45C6F390
