-carm

-Z(CODE)PATCH_BACK_ACT=10EF1624
-Z(CODE)PATCH_GET_OPNAME=10F4B250
-Z(CODE)PATCH_NEW_PG=11A0B764

-Z(CODE)PATCH_BODY,CODE,DATA_C,INITTAB=12100140
