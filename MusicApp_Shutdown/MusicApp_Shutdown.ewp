# IAR project MusicApp_Shutdown.ewp, settings and files
configuration G502_R1FA037 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG; A2; DB3150v1; G502_R1FA037
  ICCARM.PreInclude: Target\G502_R1FA037.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: G502_R1FA037; DB3150v1; A2
  XLINK.XclFile: xcl\G502_R1FA037.xcl
  group (top)
    ./: main.c
  group ASM
    asm/: G502_R1FA037.asm
