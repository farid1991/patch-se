# IAR project MediaPlayerSkinner.ewp, settings and files
configuration K800_R8BF003 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
  group (top)
    ./: CurrentTrack.c data.c Draw.c main.c skinselect.c StrLib.c
  group ASM
    temp/: temp.asm
