# IAR project AdvButton.ewp, settings and files
configuration K600_R2BB001 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration K750_R1CA021 (ARM)
  as the first configuration, except:
configuration W700_R1CA021 (ARM)
  as the first configuration, except:
configuration W800_R1BD001 (ARM)
  as the first configuration, except:
configuration Z520_R3J017 (ARM)
  as the first configuration, except:
  group (top)
    ./: book_names.c bookman.c main.c quickaccessmenu.c screenshot.c shortcut.c
  group ASM
    temp/: temp.asm
