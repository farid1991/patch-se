//K600_R2BB001
-carm
-Z(CODE)CODE,DATA_C=21478230
-Z(CODE)PATCH_KEYHANDLER=2025C75C
-Z(CODE)PATCH_FIX_VCKEY=2025CA10
