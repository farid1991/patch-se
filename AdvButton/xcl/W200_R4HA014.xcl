//W200_R4HA014
-carm
-Z(CODE)CODE,DATA_C=45555D20
-Z(CODE)PATCH_KEYHANDLER=45113000
-Z(CODE)PATCH_FIX_MPKEY=45113278
-Z(CODE)PATCH_LONG_MPKEY=451132DC
