//W800_R1BD001
-carm
-Z(CODE)CODE,DATA_C=45206600
-Z(CODE)PATCH_KEYHANDLER=44E822A0
-Z(CODE)PATCH_FIX_MPKEY=44E82464
