//W900_R5BC004
-carm
-Z(CODE)CODE,DATA_C=21A6E5D0
-Z(CODE)PATCH_KEYHANDLER=20466EB0
-Z(CODE)PATCH_FIX_IKEY=20467080
-Z(CODE)PATCH_FIX_TKEY=204670D8
-Z(CODE)PATCH_FIX_VCKEY=2046707C
