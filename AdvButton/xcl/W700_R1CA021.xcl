//W700_R1CA021
-carm
-Z(CODE)CODE,DATA_C=451EF500
-Z(CODE)PATCH_KEYHANDLER=44E88338
-Z(CODE)PATCH_FIX_MPKEY=44E884FC
