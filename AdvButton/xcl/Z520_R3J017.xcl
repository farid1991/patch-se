//Z520_R3J017
-carm
-Z(CODE)CODE,DATA_C=45198000
-Z(CODE)PATCH_KEYHANDLER=44E4F90C
-Z(CODE)PATCH_FIX_MPKEY=44E4FAD8
