//Z520_R3J017
-carm
-Z(CODE)CODE,DATA_C=45198000
-Z(CODE)PATCH_FIX_OPBUTTON=44E4FAD8
-Z(CODE)PATCH_STANDBY_EVENT=44E4F90C
