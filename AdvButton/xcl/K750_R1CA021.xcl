//K750_R1CA021
-carm
-Z(CODE)CODE,DATA_C=451E0000
-Z(CODE)PATCH_KEYHANDLER=44E79CFC
-Z(CODE)PATCH_FIX_PLAYKEY=44E79EC4
-Z(CODE)PATCH_FIX_TASKKEY=44E79F04
