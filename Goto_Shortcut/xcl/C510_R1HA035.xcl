//C510_R1HA035
-carm
-Z(CODE)CODE,DATA_C,INITTAB=15DD5000
-Z(CODE)PATCH_RIGHT_SOFTKEY_FIX1=14F733FC
-Z(CODE)PATCH_RIGHT_SOFTKEY_FIX2=14F735EC
-Z(CODE)STANDBY_LINK_RIGHT=14F735E0
