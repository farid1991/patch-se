//W200_R4HA014
-carm
-Z(CODE)CODE,DATA_C=45558520
-Z(CODE)STANDBY_LINK_LEFT=44FD2FF0
-Z(CODE)STANDBY_SOFTKEY_LEFT=44FD2FF4
