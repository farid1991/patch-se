//G502_R1FA037
-carm
-Z(CODE)CODE,DATA_C=120E83A0 //12100A80
-Z(CODE)STANDBY_SOFTKEY_RIGHT=116CEBEC
-Z(CODE)STANDBY_LINK_RIGHT=116CEBF0
