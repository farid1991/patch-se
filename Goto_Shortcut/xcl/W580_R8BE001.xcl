//W580_R8BE001
-carm
-Z(CODE)CODE,DATA_C=45DDA000
-Z(CODE)STANDBY_SOFTKEY=452BFA04
-Z(CODE)STANDBY_LINK=452BFA00
