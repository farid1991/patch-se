//W595_R3EF001
-carm
-Z(CODE)CODE,DATA_C=127F1A80
-Z(CODE)STANDBY_SOFTKEY_RIGHT=10D911A8
-Z(CODE)STANDBY_LINK_RIGHT=10D911AC
