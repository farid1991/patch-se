//W508_R1FA035
-carm
-Z(CODE)CODE,DATA_C,INITTAB=15CD1010
-Z(CODE)PATCH_RIGHT_SOFTKEY=14F08544
-Z(CODE)STANDBY_LINK_RIGHT=14F08700