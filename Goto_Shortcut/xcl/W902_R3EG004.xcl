//W902_R3EG004
-carm
-Z(CODE)CODE,DATA_C=12825A80
-Z(CODE)STANDBY_SOFTKEY_RIGHT=10D99524
-Z(CODE)STANDBY_LINK_RIGHT=10D99528
