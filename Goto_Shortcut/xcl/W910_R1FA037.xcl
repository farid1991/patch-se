//W910_R1FA037
-carm
-Z(CODE)CODE,DATA_C=12242A90
-Z(CODE)STANDBY_SOFTKEY_RIGHT=1169E088
-Z(CODE)STANDBY_LINK_RIGHT=1169E08C
