//W715_R1GA030
-carm
-Z(CODE)CODE,DATA_C=15DE9470
-Z(CODE)PATCH_RIGHT_SOFTKEY=1503CE9C
-Z(CODE)STANDBY_LINK_RIGHT=1503D080
