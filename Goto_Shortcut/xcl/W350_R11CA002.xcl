//W350_R11CA002
-carm
-Z(CODE)CODE,DATA_C=21902090
-Z(CODE)STANDBY_SOFTKEY_LEFT=210667B8
-Z(CODE)STANDBY_LINK_LEFT=210667B4
