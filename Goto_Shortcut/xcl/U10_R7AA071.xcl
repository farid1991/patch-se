//U10_R7AA071
-carm
-Z(CODE)CODE,DATA_C,INITTAB=162C2150
-Z(CODE)STANDBY_LINK_RIGHT=145579E0
