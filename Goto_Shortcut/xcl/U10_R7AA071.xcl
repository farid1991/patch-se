//U10_R7AA071
-carm
-Z(CODE)CODE,DATA_C,INITTAB=162C2080
//-Z(CODE)PATCH_RIGHT_SOFTKEY_FIX1=14F733FC
//-Z(CODE)PATCH_RIGHT_SOFTKEY_FIX2=14F735EC
-Z(CODE)STANDBY_LINK_RIGHT=145579E0
