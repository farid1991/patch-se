//K800_R8BF003
-carm
-Z(CODE)CODE,DATA_C=45DC0000
-Z(CODE)STANDBY_SOFTKEY=453BFBC8
-Z(CODE)STANDBY_LINK=453BFBC4
