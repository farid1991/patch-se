//K630_R1FA032
-carm
-Z(CODE)CODE,DATA_C=1201A220
-Z(CODE)STANDBY_SOFTKEY_RIGHT=116628E4
-Z(CODE)STANDBY_LINK_RIGHT=116628E8
