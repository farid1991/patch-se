//K600_R2BB001
-carm
-Z(CODE)CODE,DATA_C=21476560
-Z(CODE)STANDBY_SOFTKEY_LEFT=207641F8
-Z(CODE)STANDBY_LINK_LEFT=207641F4
