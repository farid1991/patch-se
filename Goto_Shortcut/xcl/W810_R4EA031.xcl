//W810_R4EA031
-carm
-Z(CODE)CODE,DATA_C=457030C0
-Z(CODE)STANDBY_SOFTKEY_LEFT=4515BBAC
-Z(CODE)STANDBY_LINK_LEFT=4515BBA8
