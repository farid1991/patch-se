//W980_R3EG004
-carm
-Z(CODE)CODE,DATA_C,INITTAB=127C0000
-Z(CODE)STANDBY_SOFTKEY_RIGHT=10D904E4
-Z(CODE)STANDBY_LINK_RIGHT=10D904E8
