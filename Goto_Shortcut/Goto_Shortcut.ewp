# IAR project Goto_Shortcut.ewp, settings and files
configuration C510_R1HA035 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: temp\temp.xcl
configuration G502_R1FA037 (ARM)
  as the first configuration, except:
configuration J105_R1HA035 (ARM)
  as the first configuration, except:
configuration K630_R1FA032 (ARM)
  as the first configuration, except:
configuration U10_R7AA071 (ARM)
  as the first configuration, except:
configuration W350_R11CA002 (ARM)
  as the first configuration, except:
configuration W508_R1FA035 (ARM)
  as the first configuration, except:
configuration W580_R8BE001 (ARM)
  as the first configuration, except:
configuration W810_R4EA031 (ARM)
  as the first configuration, except:
configuration W980_R3EG004 (ARM)
  as the first configuration, except:
  group (top)
    ./: editor.c FileFolder.c main.c strlib.c utils.c
  group asm
    temp/: temp.asm
